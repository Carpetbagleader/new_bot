Commit message: edited robot urdf to match rp lidar driver

File: description/robot_core.xacro (robot description, xacro)
@@ -163,5 +163,5 @@
   </joint>
 <!-- LIDAR LINK-->
-  <link name="laser_frame">
+  <link name="laser">
     <inertial>
       <origin
